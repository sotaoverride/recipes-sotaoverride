inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-async-timeout"

# initial_rev: 90bc4d4d7a0f8cab41ed146b80b0d809731535b2
