inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-dotenv"

# initial_rev: e6e77bd5a0079a2e85279731d495785b50efbf3d
