inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-h11"

# initial_rev: 6cf707a9833deda330bfa802ab10768ae879e627
