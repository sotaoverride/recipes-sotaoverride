inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-pyserial"

# initial_rev: ee1e4fbbc1fd3ad66714c88f9d53bf6773908a13
