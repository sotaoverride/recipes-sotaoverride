inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/notify-server"
EXTERNALSRC_BUILD = "/home/ubuntu/oe-core/build/workspace/sources/notify-server"

# initial_rev: bf8fbe8a98c14061af8d5bbb22d7a6b95a25eaab
