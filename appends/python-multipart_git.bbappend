inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python-multipart"

# initial_rev: ed8c47aa9f9011f5c5e1fe0d1ac53cdd026acaed
