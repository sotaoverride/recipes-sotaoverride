inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python-yaml"

# initial_rev: ee37f4653c08fc07aecff69cfd92848e6b1a540e
