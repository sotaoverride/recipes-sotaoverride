inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/opentrons"
EXTERNALSRC_BUILD = "/home/ubuntu/oe-core/build/workspace/sources/opentrons"

# initial_rev: bf8fbe8a98c14061af8d5bbb22d7a6b95a25eaab
