inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-typing-extensions"

# initial_rev: c2271dafda38f449f36844fdad9a7b492271ddda
