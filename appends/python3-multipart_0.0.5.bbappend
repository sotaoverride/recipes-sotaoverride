inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-multipart"

# initial_rev: e291aae1632078f73f14225b1e8cdcead395b96c
