inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-fastapi"

# initial_rev: cb80a74dd03af5160b581252a9497f75e66e37e9
