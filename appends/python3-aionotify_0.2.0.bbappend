inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-aionotify"

# initial_rev: 566ac017e6272b49c4058d403ce74415e6d0e178
