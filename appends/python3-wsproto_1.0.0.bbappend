inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-wsproto"

# initial_rev: 971b89c6a2a4f739fcf6b18e25d9ee712ff2b8e4
