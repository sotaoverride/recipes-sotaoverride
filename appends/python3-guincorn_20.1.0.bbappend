inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-guincorn"

# initial_rev: 755746095a62a27718c6a4508ca6ba0bc966992d
