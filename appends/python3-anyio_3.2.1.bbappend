inherit externalsrc
EXTERNALSRC = "/home/ubuntu/oe-core/build/workspace/sources/python3-anyio"

# initial_rev: 09a0d84033511a698c298403b71ccc38d6753271
